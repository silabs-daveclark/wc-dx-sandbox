# Keil uVision project udp_client.uvprojx, settings and files
target udp_client (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F411RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x08000000-0x0807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  c flags: Optim=1 OneElfS=1 wLevel=1
  c define: USE_HAL_DRIVER,STM32F411xE,RSI_WITH_OS,RSI_WLAN_ENABLE,RSI_UART_INTERFACE,RSI_SAMPLE_HAL WINDOWS RSI_STM32
  c misc: --C99 --reduce_paths
  c include: ..\..\..\Core\Inc;..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\Drivers\CMSIS/Device\ST\STM32F4xx\Include;..\..\..\..\..\..\..\sapis\examples\wlan\udp_client;..\..\..\..\..\..\..\sapis\include;..\..\..\..\..\..\..\sapis\rom;..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include;..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS_V2;..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x90000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
--reduce_paths
  group Application/MDK-ARM
    ../../../Core/startup/: startup_stm32f411xe.s
  group Application/User
    ../../../Core/Src/: stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../../../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group common
    ../../../../../../../sapis/common/: rsi_common_apis.c rsi_device_init_apis.c
  group driver
    ../../../../../../../sapis/driver/: rsi_common.c rsi_device_init.c rsi_driver.c rsi_driver_event_handlers.c rsi_events.c rsi_nwk.c rsi_os_none.c rsi_pkt_mgmt.c rsi_queue.c rsi_scheduler.c rsi_timer.c rsi_utils.c rsi_wlan.c
  group example
    ../../../../../../../sapis/examples/wlan/udp_client/: rsi_udp_client.c
  group hal
    ../../../../../hal/: rsi_hal_mcu_interrupt.c rsi_hal_mcu_ioports.c rsi_hal_mcu_timer.c rsi_hal_mcu_uart.c rsi_timer.c rsi_hal_mcu_platform_init.c
  group intf_uart
    ../../../../../../../sapis/driver/intf/uart/: rsi_uart.c
  group include
    ../../../../../../../sapis/include/: rsi_common.h rsi_common_apis.h rsi_driver.h rsi_error.h rsi_events.h rsi_hal.h rsi_iap.h rsi_mac_api.h rsi_mac_interface.h rsi_nwk.h rsi_os.h rsi_pkt_mgmt.h rsi_puf.h rsi_queue.h rsi_scheduler.h rsi_socket.h rsi_timer.h rsi_uart.h rsi_utils.h rsi_wlan.h rsi_wlan_apis.h rsi_wlan_defines.h
  group nwk
    ../../../../../../../sapis/nwk/socket/: rsi_socket.c
  group rom
    ../../../../../../../sapis/rom/: rsi_apis_non_rom.c rsi_apis_rom.c rsi_apis_rom.h rsi_events_rom.c rsi_nwk_rom.c rsi_pkt_mgmt_rom.c rsi_queue_rom.c rsi_scheduler_rom.c rsi_socket_rom.c rsi_utils_rom.c
  group wlan
    ../../../../../../../sapis/wlan/: rsi_wlan_apis.c
  group os
    ../../../../../../../sapis/os/free_rtos/: rsi_os_wrapper.c
software components: CMSIS:CORE 4.1.0
