# Keil uVision project AWS_IoT.uvprojx, settings and files
target AWS_IoT (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F411RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x08000000-0x0807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: aws_iot
  c flags: Optim=1 OneElfS=1 wLevel=1
  c define: USE_HAL_DRIVER STM32F411xE RSI_SPI_INTERFACE,RSI_SAMPLE_HAL RSI_WLAN_ENABLE RSI_SPI_HIGH_SPEED_ENABLE RSI_DEBUG_PRINTS
  c misc: --C99 --reduce_paths
  c include: ..\..\..\Core\Inc;..\..\..\..\..\Drivers/STM32F4xx_HAL_Driver/Inc;..\..\..\..\..\Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;..\..\..\..\..\Drivers/CMSIS/Include;..\..\..\..\..\Drivers/CMSIS/Device/ST/STM32F4xx/Include;..\..\..\..\..\..\..\sapis\rom\;..\..\..\..\..\..\..\sapis\include;..\..\..\..\..\..\..\sapis\puf;..\..\..\..\..\..\..\sapis\applications\;..\..\..\..\..\..\..\sapis\nwk\applications\http_server;..\..\..\..\..\..\..\sapis\nwk\applications\mdnsd_records;..\..\..\..\..\..\..\sapis\nwk\applications\mqtt_client\src;..\..\..\..\..\..\..\sapis\nwk\applications\mqtt_client\src\MQTTPacket\src;..\..\..\..\..\..\..\sapis\nwk\applications\aws_sdk\include;..\..\..\..\..\..\..\sapis\nwk\applications\aws_sdk\platform\inc;..\..\..\..\..\..\..\sapis\examples\utilities\certificates\;..\..\..\..\..\..\..\sapis\examples\wlan\cloud\aws_iot\device_shadow
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
--reduce_paths
  group Application/MDK-ARM
    ../../../Core/startup/: startup_stm32f411xe.s
  group Application/User
    ../../../Core/Src/: stm32f4xx_hal_msp.c stm32f4xx_it.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_dma.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_spi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_pwr.c stm32f4xx_hal.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../../../Core/Src/: system_stm32f4xx.c
  group common
    ../../../../../../../sapis/common/: rsi_common_apis.c rsi_device_init_apis.c
  group driver
    ../../../../../../../sapis/driver/: rsi_bt_ble.c rsi_common.c rsi_device_init.c rsi_driver.c rsi_driver_event_handlers.c rsi_events.c rsi_iap.c rsi_nwk.c rsi_os_none.c rsi_pkt_mgmt.c rsi_queue.c rsi_scheduler.c rsi_setregion_countryinfo.c rsi_timer.c rsi_utils.c rsi_wlan.c rsi_zb.c rsi_zb_utility.c
  group example
    ../../../../../../../sapis/examples/wlan/cloud/aws_iot/device_shadow/: rsi_shadow_sample.c
  group hal
    ../../../../../hal/: rsi_hal_mcu_interrupt.c rsi_hal_mcu_ioports.c rsi_hal_mcu_platform_init.c rsi_hal_mcu_random.c rsi_hal_mcu_spi.c rsi_hal_mcu_timer.c rsi_hal_mcu_uart.c rsi_timer.c
  group intf_spi
    ../../../../../../../sapis/driver/intf/spi/: rsi_spi_frame_rd_wr.c rsi_spi_functs.c rsi_spi_iface_init.c rsi_spi_mem_rd_wr.c rsi_spi_reg_rd_wr.c
  group Include
    ../../../../../../../sapis/include/: rsi_ant.h rsi_ble.h rsi_ble_apis.h rsi_bootup_config.h rsi_bt.h rsi_bt_apis.h rsi_bt_common.h rsi_bt_common_apis.h rsi_bt_sbc_codec.h rsi_bt_sdp.h rsi_common.h rsi_common_apis.h rsi_crypto.h rsi_data_types.h rsi_driver.h rsi_error.h rsi_events.h rsi_hal.h rsi_hid.h rsi_iap.h rsi_mac_api.h rsi_mac_interface.h rsi_nwk.h rsi_os.h rsi_pkt_mgmt.h rsi_puf.h rsi_qspi_defines.h rsi_queue.h rsi_scheduler.h rsi_sdio.h rsi_setregion_countryinfo.h rsi_socket.h rsi_spi_cmd.h rsi_spi_intf.h rsi_timer.h rsi_uart.h rsi_user.h rsi_utils.h rsi_wisemcu_hardware_setup.h rsi_wlan.h rsi_wlan_apis.h rsi_wlan_common_config.h rsi_wlan_defines.h rsi_wlan_non_rom.h rsi_zb_api.h rsi_zb_frames.h rsi_zb_interfaces.h rsi_zb_types.h rsi_ble_common_config.h rsi_bt_common_config.h
  group nwk
    ../../../../../../../sapis/nwk/applications/http_server/: rsi_http_server.c rsi_json_handlers.c
    ../../../../../../../sapis/nwk/applications/: rsi_ota_fw_up.c rsi_dhcp_user_class.c rsi_dns.c rsi_firmware_upgradation.c rsi_ftp.c rsi_http_client.c rsi_mdnsd.c rsi_multicast.c rsi_pop3_client.c rsi_raw_data.c rsi_smtp_client.c rsi_sntp_client.c rsi_web_socket.c
    ../../../../../../../sapis/nwk/applications/mdnsd_records/: rsi_mdnsd_records.c
    ../../../../../../../sapis/nwk/socket/: rsi_socket.c
  group puf
    ../../../../../../../sapis/puf/: rsi_puf.c
  group rom
    ../../../../../../../sapis/rom/: rsi_apis_non_rom.c rsi_apis_rom.c rsi_events_rom.c rsi_pkt_mgmt_rom.c rsi_queue_rom.c rsi_scheduler_rom.c rsi_socket_rom.c rsi_nwk_rom.c rsi_utils_rom.c
  group wlan
    ../../../../../../../sapis/wlan/: rsi_wlan_apis.c
  group AWS_SDK
    ../../../../../../../sapis/nwk/applications/aws_sdk/src/: aws_iot_jobs_topics.c aws_iot_jobs_interface.c aws_iot_jobs_json.c aws_iot_jobs_types.c aws_iot_json_utils.c aws_iot_mqtt_client.c aws_iot_mqtt_client_common_internal.c aws_iot_mqtt_client_connect.c aws_iot_mqtt_client_publish.c aws_iot_mqtt_client_subscribe.c aws_iot_mqtt_client_unsubscribe.c aws_iot_mqtt_client_yield.c aws_iot_shadow.c aws_iot_shadow_actions.c aws_iot_shadow_json.c aws_iot_shadow_records.c jsmn.c
    ../../../../../../../sapis/nwk/applications/aws_sdk/platform/src/: network_wrapper.c timer.c
